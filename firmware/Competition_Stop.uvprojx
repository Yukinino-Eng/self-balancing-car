# Keil uVision project Competition_Stop.uvprojx, settings and files
target Competition_Stop_Simulator (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: competition_stop +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,PD_GROUND_TEST,PD_HOLD_TEST,PARALLEL_PID_TRIAL,LEARN_SIMULATOR,PERIPHERAL_SELFTEST,REVIEW_ONLY_SELFTEST,STOP_HOLD_ONLY_SELFTEST
  c include: .\Libraries\Device;.\Libraries\CMSIS;.;.\tests
  asm define: STM32F10X_MD
  asm include: .\Libraries\Device;.\Libraries\CMSIS;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\memory.sct
  group Competition
    ./tests/: selftest_stop_hold.c runner.c selftest_review.c selftest.h selftest_distance.c selftest_competition.c parameter_fixture63.h
    ./: board.c encoder.c imu.c balance_preview.c motor_guard.c pd_window.c hold_tuning.c speed_loop.c param_store.c local_control.c task_motion.c wheel_odometry.c peripherals.c main.c runtime.c pitch_uart.c balance_preview.h board.h encoder.h hold_config.h hold_tuning.h imu.h local_control.h motor_guard.h parallel_trial_config.h param_store.h pd_window.h peripherals.h runtime.h speed_loop.h task_motion.h tilt_config.h vl53l1x_boot_config.h wheel_odometry.h pitch_uart.h
    ./Libraries/Startup/: startup_stm32f10x_md.s
